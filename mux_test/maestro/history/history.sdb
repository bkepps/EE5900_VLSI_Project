<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 19 16:14:18 2025</timestamp>
			<uuid>{9572fa8d-2c5e-4c86-8a09-a2f536422ff4}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/campus15/mmunoria/Group2_VLSI_EE5900/mux_test/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>/home/campus15/mmunoria/Group2_VLSI_EE5900/mux_test/maestro/results/maestro/ExplorerRun.0.rdb</simresults>
			<runlog>/home/campus15/mmunoria/Group2_VLSI_EE5900/mux_test/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/mux_test/maestro/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/mux_test/maestro/results/maestro/ExplorerRun.0</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
