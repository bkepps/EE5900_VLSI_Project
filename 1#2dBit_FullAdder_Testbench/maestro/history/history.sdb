<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 10 17:14:44 2025</timestamp>
			<uuid>{c982e91b-a2c1-4a50-b480-875e9cb655ae}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/campus15/mmunoria/Group2_VLSI_EE5900/1#2dBit_FullAdder_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>/home/campus15/mmunoria/Group2_VLSI_EE5900/1#2dBit_FullAdder_Testbench/maestro/results/maestro/ExplorerRun.0.rdb</simresults>
			<runlog>/home/campus15/mmunoria/Group2_VLSI_EE5900/1#2dBit_FullAdder_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir></psfdir>
			<simdir></simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
