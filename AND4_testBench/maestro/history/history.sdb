<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 19 16:12:42 2025</timestamp>
			<uuid>{1676b7d9-1233-4474-9f44-859173ac18bb}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/campus15/mmunoria/Group2_VLSI_EE5900/AND4_testBench/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>/home/campus15/mmunoria/Group2_VLSI_EE5900/AND4_testBench/maestro/results/maestro/ExplorerRun.0.rdb</simresults>
			<runlog>/home/campus15/mmunoria/Group2_VLSI_EE5900/AND4_testBench/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/AND4_testBench/maestro/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/AND4_testBench/maestro/results/maestro/ExplorerRun.0</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
