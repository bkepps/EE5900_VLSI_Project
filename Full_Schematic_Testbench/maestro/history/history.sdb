<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Dec 9 17:18:37 2025</timestamp>
			<uuid>{688264c0-4ab2-4716-8cce-6eebedbcb301}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/campus31/bskepper/Group2_VLSI_EE5900/Group2_VLSI_EE5900/Full_Schematic_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/campus31/bskepper/Group2_VLSI_EE5900/Group2_VLSI_EE5900/Full_Schematic_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/campus31/bskepper/cadence/simulation/Group2_VLSI_EE5900/Full_Schematic_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/Group2_VLSI_EE5900/Full_Schematic_Testbench/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
