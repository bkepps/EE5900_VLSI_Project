<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 19 15:43:53 2025</timestamp>
			<uuid>{09444dcc-2c2a-457a-8c12-109738c6c1b2}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/campus15/mmunoria/Group2_VLSI_EE5900/not_testBench/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>/home/campus15/mmunoria/Group2_VLSI_EE5900/not_testBench/maestro/results/maestro/ExplorerRun.0.rdb</simresults>
			<runlog>/home/campus15/mmunoria/Group2_VLSI_EE5900/not_testBench/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/not_testBench/maestro/results/maestro/ExplorerRun.0</psfdir>
			<simdir>/home/campus15/mmunoria/cadence/simulation/Group2_VLSI_EE5900/not_testBench/maestro/results/maestro/ExplorerRun.0</simdir>
			<historyPsfSize>Not Computed</historyPsfSize>
		</historyentry>
	</history>
</setupdb>
